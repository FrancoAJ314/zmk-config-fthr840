## boards/arm/fthr840_mouse/Kconfig.board
```kconfig
config BOARD_FTHR840_MOUSE
    bool "fthr840_mouse"
    depends on SOC_NRF52840_QIAA
```
